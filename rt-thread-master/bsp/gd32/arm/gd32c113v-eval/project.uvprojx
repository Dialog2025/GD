# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C113VB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__
  c include: ..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\posix\io\poll;packages\gd32-arm-cmsis-latest\GD32C11x;..\..\..\..\components\libc\compilers\common\extension;board;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\include;..\..\..\..\components\finsh;..\..\..\..\include;..\..\..\..\components\drivers\smp_call;..\libraries\gd32_drivers;..\..\..\..\components\libc\posix\ipc;..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\posix\io\epoll;.;..\..\..\..\libcpu\arm\cortex-m4;applications;..\..\..\..\components\drivers\include;packages\gd32-arm-series-latest\GD32C11x\standard_peripheral\Include;.\at24cxx-master
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
    ./at24cxx-master/: at24cxx.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/i2c/: dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_i2c.c
  group Finsh
    ../../../../components/finsh/: msh.c shell.c cmd.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsnprintf_tiny.c kstring.c kstdio.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ./packages/gd32-arm-series-latest/GD32C11x/standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
    ./packages/gd32-arm-cmsis-latest/GD32C11x/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
    ./packages/gd32-arm-cmsis-latest/GD32C11x/GD/GD32C11x/Source/: system_gd32c11x.c
software components: CMSIS:CORE 5.5.0
