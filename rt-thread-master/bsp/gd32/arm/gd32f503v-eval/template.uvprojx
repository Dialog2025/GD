# Keil uVision project template.uvprojx, settings and files
target rt-thread (6160001::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x030000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: GD32F50X, GD32F503
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
software components: CMSIS:CORE 5.4.0
