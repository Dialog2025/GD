# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160001::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x030000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__
  c include: ..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension;packages\gd32-arm-cmsis-latest\GD32F50x\Include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\spi;..\..\..\..\libcpu\arm\common;packages\gd32-arm-series-latest\GD32F50x\Include;board;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\finsh;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\posix\io\poll;.;applications;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\include;packages\gd32-arm-cmsis-latest\GD32F50x\Include;..\..\..\..\libcpu\arm\cortex-m4;packages\gd32-arm-series-latest\GD32F50x\Include;..\..\..\..\include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\libc\posix\ipc;libraries\gd32_drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c
    packages/gd32-arm-series-latest/GD32F50x/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
    libraries/gd32_drivers/: drv_gpio.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c msh.c cmd.c shell.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
software components: CMSIS:CORE 5.4.0
