# Keil uVision project template.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM(0x20000000-0x20030000) IROM(0x08000000-0x08080000) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
