# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, GD32F527, RT_USING_ARMLIBC, __RTTHREAD__, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;applications;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\drivers\include;.;..\..\..\..\components\finsh;..\..\..\..\components\libc\posix\ipc;..\libraries\gd32_drivers;..\..\..\..\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board;..\..\..\..\libcpu\arm\common;..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;packages\gd32-arm-series-latest\GD32F5xx\GD32F5xx_standard_peripheral\Include;..\..\..\..\components\libc\compilers\common\extension;packages\gd32-arm-cmsis-latest\GD32F5xx;..\..\..\..\components\libc\posix\io\epoll;packages\gd32-arm-cmsis-latest\GD32F5xx\GD\GD32F5xx\Include;.\at24cxx-master
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./at24cxx-master/: at24cxx.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../../components/drivers/i2c/: dev_i2c_core.c dev_i2c_dev.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_i2c.c
    ./packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_spi.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../../../components/finsh/: msh.c cmd.c msh_parse.c shell.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c kstdio.c rt_vsscanf.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/ARM/: startup_gd32f5xx.s
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/: system_gd32f5xx.c
    packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_dma.c gd32f5xx_exti.c gd32f5xx_gpio.c gd32f5xx_misc.c gd32f5xx_rcu.c gd32f5xx_syscfg.c gd32f5xx_usart.c
    ./packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_i2c.c gd32f5xx_i2c_add.c
software components: CMSIS:CORE 5.6.0
